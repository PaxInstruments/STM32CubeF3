# Keil uVision project Project.uvprojx, settings and files
target STM32303E_EVAL (ARM-ADS)
  device: STM32F303VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x08000000-0x807FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32303E_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE,USE_STM32303E_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32303E_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal.c stm32f3xx_hal_i2s.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_i2c.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_spi.c
  group Drivers/BSP/STM32303E_EVAL
    ../../../../../../Drivers/BSP/STM32303E_EVAL/: stm32303e_eval_lcd.c stm32303e_eval_audio.c stm32303e_eval.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../../Drivers/BSP/Components/cs42l52/: cs42l52.c
    ../../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
  group Example/User
    ../Src/: stm32f3xx_it.c stm32f3xx_hal_msp.c main.c
  group Example/MDK-ARM
    ./: startup_stm32f303xe.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.1.0
