# Keil uVision project Project.uvprojx, settings and files
target STM32373C_EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F373VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x803FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32373C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F373xC,USE_HAL_DRIVER,USE_STM32373C_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32373C_EVAL;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Utilities\Log;..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f373xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/User
    ../Src/: joystick.c temperature_sensor.c audio_play.c sd.c main.c stm32f3xx_it.c eeprom.c log.c lcd.c hdmi_cec.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ili9328/: ili9328.c
    ../../../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../Drivers/BSP/Components/stlm75/: stlm75.c
  group Drivers/BSP/STM32373C_EVAL
    ../../../../../Drivers/BSP/STM32373C_EVAL/: stm32373c_eval_audio.c stm32373c_eval_sd.c stm32373c_eval.c stm32373c_eval_eeprom.c stm32373c_eval_cec.c stm32373c_eval_tsensor.c stm32373c_eval_lcd.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_cec.c stm32f3xx_hal_dma.c stm32f3xx_hal_uart.c stm32f3xx_hal_pwr.c stm32f3xx_hal_i2s.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_i2c.c stm32f3xx_hal_spi.c stm32f3xx_hal.c stm32f3xx_hal_rcc_ex.c
software components: CMSIS:CORE 4.1.0
