# Keil uVision project Project.uvprojx, settings and files
target STM32F303ZE-Nucleo (ARM-ADS)
  device: STM32F303ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x807FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F303ZE-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE,USE_STM32F3XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F3xx_Nucleo_144
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F3xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F3xx_Nucleo_144/: stm32f3xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/MDK-ARM
    ./: startup_stm32f303xe.s
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_dma.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal.c stm32f3xx_hal_i2c.c stm32f3xx_hal_uart.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr_ex.c
  group Example/User
    ../Src/: stm32f3xx_it.c main.c stm32f3xx_hal_msp.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
