# Keil uVision project Project.uvprojx, settings and files
target STM32F334R8-Nucleo (ARM-ADS)
  device: STM32F334R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F334R8-Nucleo
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F334x8,USE_HAL_DRIVER,USE_STM32F3XX_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32F3xx-Nucleo;..\..\..\..\..\Drivers\BSP\Adafruit_Shield;..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F3xx-Nucleo
    ../../../../../Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c
  group Demo/User
    ../Src/: main.c fatfs_storage.c stm32f3xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_cortex.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
  group Example/MDK-ARM
    ./: startup_stm32f334x8.s
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Middlewares/FatFs/Drivers
    ../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.1.0
