# Keil uVision project Project.uvprojx, settings and files
target STM32F334R8-Nucleo (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F334R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F334R8-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F334x8,USE_HAL_DRIVER,USE_STM32F3XX_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F3xx-Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F3xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Example/User
    ../Src/: stm32f3xx_lp_modes.c main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_rcc.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal.c stm32f3xx_hal_gpio.c stm32f3xx_hal_flash_ex.c
software components: CMSIS:CORE 4.1.0
